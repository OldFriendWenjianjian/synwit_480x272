# Keil uVision project app.uvprojx, settings and files
target SWM34SVET6_A3_Debug (6240000::V6.24::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.2.2.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: app +hex
  BeforeMake: default_appkit.bat
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3
  c define: SWM34SVET6_A3
  c include: .\src\CSL\CMSIS\CoreSupport;.\src\CSL\CMSIS\DeviceSupport;.\src\CSL\SWM341_StdPeriph_Driver;.\src\CSL\SWM341_UsbHost_Lib;.\src\CSL\SWM341_UsbHost_Lib\MSC;..\lvgl;..\framework;..\framework\export;.\src\apps;.\src\board;.\src\peripheral;.\src\mass_storage;.\src\FatFs;.\src\lv_porting;.\src\apps\ui_src\appkit;.\src\apps\ui_src\appkit\screens
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\src\apps\SWM341_stdperiph_lib.sct
  group lv_core
    ../lvgl/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
  group lv_draw
    ../lvgl/lvgl/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group lv_font
    ../lvgl/lvgl/src/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lv_fs_if
    ../lvgl/lvgl/src/lv_fs_if/: lv_fs_if.c
  group lv_gpu
    ../lvgl/lvgl/src/lv_gpu/: lv_gpu_swm341_dma2d.c
  group lv_hal
    ../lvgl/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lv_misc
    ../lvgl/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lv_themes
    ../lvgl/lvgl/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
  group lv_widgets
    ../lvgl/lvgl/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_win.c
  group apps
    ./src/apps/: bootscreen.c main.c app_usbmsc.c
  group data_provider
    ./src/data_provider/: data_provider.h data_provider_fs.c data_provider_spiflash.c
  group serial_display
    ./src/apps/serial_display/: serial_display_process.c serial_display_process.h
    ./src/apps/synwit_ui_framework/utils/serial_display/: serial_display_client.c
  group board\common
    ./src/board/: board.c
    ./src/board/swm34s/common/jpeg/: dev_jpeg.c
    ./src/board/swm34s/common/sdram/: dev_sdram.c
    ./src/board/swm34s/common/systick/: dev_systick.c
    ./src/board/swm34s/common/uart/: dev_uart.c
    ./src/board/swm34s/common/dac/: dev_dac.c
    ./src/board/swm34s/common/i2s/: dev_i2s.c
    ./src/board/swm34s/common/spi/: dev_lcd_spi.c
  group board\swm34svet6_a3
    ./src/board/swm34s/swm34svet6/a3/: dev_tp.c dev_i2c1_sensor.c dev_lcdc.c
  group board\swm34svet6_a1
    ./src/board/swm34s/swm34svet6/a1/: dev_tp.c dev_lcdc.c
  group board\swm34sre_a1
    ./src/board/swm34s/swm34sre/a1/: dev_tp.c dev_lcdc.c
  group board\swm34sce_a1
    ./src/board/swm34s/swm34sce/a1/: dev_tp.c dev_lcdc.c
  group board\swm34sme_a1
    ./src/board/swm34s/swm34sme/a1/: dev_tp.c dev_lcdc.c
  group peripheral
    ./src/peripheral/tp/: peripheral_tp.c tp_gt9x.c tp_ft6336.c tp_ft5426.c tp_cst826.c tp_cst3xx.c
    ./src/peripheral/lcd/: peripheral_lcd.c lcd_generic.c lcd_480x480_round.c lcd_480x480_square.c lcd_jlt35002a_v3_mpu.c lcd_jlt35002a_v3_spi.c lcd_jlt35002a_v2_rgb.c lcd_yh032qv_mpu.c
    ./src/peripheral/pressure/: pressure_manager.c
  group mass_storage
    ./src/mass_storage/: descriptors.c FlashDisk.c MassStorage.c
  group FatFs
    ./src/FatFs/: diskio.c ff.c ffunicode.c
  group CSL\StdPD
    ./src/CSL/SWM341_StdPeriph_Driver/: SWM341_adc.c SWM341_can.c SWM341_cordic.c SWM341_crc.c SWM341_dac.c SWM341_div.c SWM341_dma.c SWM341_dma2d.c SWM341_exti.c SWM341_flash.c SWM341_gpio.c SWM341_i2c.c SWM341_iofilt.c SWM341_jpeg.c SWM341_lcd.c SWM341_port.c SWM341_pwm.c SWM341_qei.c SWM341_rtc.c SWM341_sdio.c SWM341_sdram.c SWM341_sfc.c SWM341_sleep.c SWM341_spi.c SWM341_timr.c SWM341_uart.c SWM341_usbd.c SWM341_usbh.c SWM341_wdt.c
  group CLS\CMSIS
    ./src/CSL/CMSIS/DeviceSupport/: system_SWM341.c
    ./src/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM341.s
  group lv_porting
    ./src/lv_porting/: lv_port_disp.c lv_port_indev.c lv_port_jpg.c jfif_parser.c avi_parser.c lv_fs_fatfs.c audio_decoder.c audio_decoder_i2s.c
  group libs
    ./libs/: framework.lib
  group ui_src\appkit
    ./src/apps/ui_src/appkit/: app.c
  group ui_src
    ./src/apps/ui_src/: screen001.c screen002.c screen003.c screen004.c screen005.c screen006.c screen007.c screen008.c screen009.c
target SWM34SVET6_A1_Debug (6160000::V6.16::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.2.2.5
  cpu: as above
  output: app +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3
  c define: SWM34SVET6_A1
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\src\apps\SWM341_stdperiph_lib.sct
target SWM34SRE_A1_Debug (6160000::V6.16::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.2.2.5
  cpu: as above
  output: app +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3
  c define: SWM34SRE_A1
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\src\apps\SWM341_stdperiph_lib.sct
target SWM34SCE_A1_Debug (6160000::V6.16::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.2.2.5
  cpu: as above
  output: app +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3
  c define: SWM34SCE_A1 MEM_SIZE_MB=2
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\src\apps\SWM341_stdperiph_lib.sct
target SWM34SME_A1_Debug (6210000::V6.21::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.2.2.5
  cpu: as above
  output: app +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3
  c define: SWM34SME_A1 MEM_SIZE_MB=2
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\src\apps\SWM341_stdperiph_lib.sct
target Release (6160000::V6.16::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.2.2.5
  cpu: as above
  output: app +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3
  c define: SWM34SVET6_A3
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\src\apps\SWM341_stdperiph_lib.sct

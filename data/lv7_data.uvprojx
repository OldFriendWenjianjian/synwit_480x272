# Keil uVision project lv7_data.uvprojx, settings and files
target data (6240000::V6.24::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.2.2.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: lv7_data
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\spiflash_data.sct
  link misc: --keep=ui_data0 --keep=ui_data1 --keep=ui_data2 --keep=ui_data3 --keep=ui_data4 --keep=ui_data5 --keep=ui_data6 --keep=ui_data7
  group appkit
    ../app/src/apps/ui_src/appkit/data/: ui_data00.c ui_data01.c ui_data02.c ui_data03.c ui_data04.c ui_data05.c ui_data06.c ui_data07.c
